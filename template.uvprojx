# Keil uVision project template.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32F401xC
  c include: .\CMSIS;.\HAL_Lib\inc;.\Timebase;.\TaskSched;.\Driver
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./startup/: startup_stm32f401xc.s
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c
  group Main
    ./Main/: main.c
  group TaskSched
    ./TaskSched/: STS.c
  group Timebase
    ./Timebase/: timebase.c
  group Driver
    ./Driver/: alarm.c buzzer.c key.c led.c uart.c
  group HAL_Lib
    ./HAL_Lib/src/: stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c
